# Extend the tisdk-uenv recipe for sa67a
# Use the uEnv-sk.txt file from j722s-evm
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/sa67:"
