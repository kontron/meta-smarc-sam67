FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fix-build-for-linux-6.18-rc1.patch"
