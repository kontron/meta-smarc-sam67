# Add the u-boot repository supporting Kontron SMARC sa67a
SRC_URI = "git://github.com/kontron/u-boot-smarc-sam67.git;protocol=https;branch=master"
SRC_URI[sha256sum] = "3caad056e1427beea4f63726331b8123398ca5ee36d2649f58b5a38b8f471e1f"

SRCREV = "2549f8e52e41d184db24da12627f94465f7538c1"

TI_DM = ""