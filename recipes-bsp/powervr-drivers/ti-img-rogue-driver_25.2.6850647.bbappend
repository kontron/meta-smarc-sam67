FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-update-to-6.19.patch"
